# Repository xiehaotian2001/F1c200s_XhtCore

File README.md:

# F1c200s_XhtCore
Not verified！A Linux card computer based on F1c200s

## KiCad design Hardware_F1c200s_XhtCore-2023-11-19END/F1c200s_XhtCore.kicad_pcb

Parts:
FID1, FID2, FID3: Fiducial; Fiducial_1mm_Mask2mm
TP1, TP5, TP6: TestPoint; TestPoint_Pad_D3.0mm

Notes on the sheet:
XieHaotian
F1C200S_XHTCORE
USB
F1CX00
https://space.bilibili.com/1855864901
Description
POWER
AUDIO&SCREEN&SD
V1.0
Page
Drawn
2023_11_19
Version_Revisions
Rev
Index
WIFI
https://xiehaotian.com/linuxpc/f1c200s-xht-core
First Release
未验证，请原谅
Date

Parts:
C25, C27: 0.1uF; C_1206_3216Metric
C28, C29: 10uF; C_1206_3216Metric
C39, C40: 0.1uF; C_0603_1608Metric
C41: 10uF; C_0603_1608Metric
D10, D11: SMAJ6.5CA; D_SMA
D12, D13: PRTR5V0U2X; SOT-143
L3, L4: SDCW3216-2-900TF; FILTER-SMD_4P-L3.2-W1.6-BL_DLW31SN; MANUFACTURER PART WCM2012F2SF-900T04; LCSC PART NAME WCM2012F2SF-900T04
R18, R19, R20, R21: 5.1k; R_0603_1608Metric
TP10, TP11, TP12: TestPoint; TestPoint_Pad_D1.5mm
U2: CH340K; ESOP-10_L4.9-W3.9-P1.00-LS6.2-BL-EP; MANUFACTURER PART CH340K; LCSC PART NAME CH340K USB转串口芯片 CH340
UNK2, UNK3: 3A; Fuse_1206_3216Metric
USB1, USB2: Type-C; USB_C_Receptacle_XKB_U262-16XN-4BVC11

Connections:
/USB/CH_CTS: TP11.1, U2.5 (CTS#)
/USB/CH_DTR: TP10.1, U2.4 (DTR#)
/USB/CH_RTS: TP12.1, U2.6 (RTS#)
/USB/USB1_1_D+: L3.1, USB1.A6 (DP1), USB1.B6 (DP2)
/USB/USB1_1_D-: L3.4, USB1.A7 (DN1), USB1.B7 (DN2)
/USB/USB1_CC1: R19.1, USB1.A5 (CC1)
/USB/USB1_CC2: R18.1, USB1.B5 (CC2)
/USB/USB1_POWER_IN: UNK2.1, USB1.A4 (VBUS), USB1.A9 (VBUS), USB1.B4 (VBUS), USB1.B9 (VBUS)
/USB/USB2_1_D+: L4.1, USB2.A6 (DP1), USB2.B6 (DP2)
/USB/USB2_1_D-: L4.4, USB2.A7 (DN1), USB2.B7 (DN2)
/USB/USB2_2_D+: D13.2 (I/O1), L4.2, U2.1 (UD+)
/USB/USB2_2_D-: D13.3 (I/O2), L4.3, U2.2 (UD-)
/USB/USB2_CC1: R21.1, USB2.A5 (CC1)
/USB/USB2_CC2: R20.1, USB2.B5 (CC2)
/USB/USB2_POWER_IN: UNK3.1, USB2.A4 (VBUS), USB2.A9 (VBUS), USB2.B4 (VBUS), USB2.B9 (VBUS)
CH_RX: U2.9 (RXD); also elsewhere on the board
CH_TX: U2.8 (TXD); also elsewhere on the board
GND: C25.2, C27.2, C28.2, C29.2, C39.2, C40.2, C41.2, D10.1 (A1), D11.1 (A1), D12.1 (GND), D13.1 (GND), R18.2, R19.2, R20.2, R21.2, U2.3 (GND), U2.11 (EP), USB1.A1 (GND), USB1.A12 (GND), USB1.B1 (GND), USB1.B12 (GND), USB1.S1 (SHIELD), USB2.A1 (GND), USB2.A12 (GND), USB2.B1 (GND), USB2.B12 (GND), USB2.S1 (SHIELD); also elsewhere on the board
unnamed: C39.1, U2.10 (V3)
USB1_2_D+: D12.2 (I/O1), L3.2; also elsewhere on the board
USB1_2_D-: D12.3 (I/O2), L3.3; also elsewhere on the board
VBUS: C25.1, C27.1, C28.1, C29.1, C40.1, C41.1, D10.2 (A2), D11.2 (A2), D12.4 (VCC), D13.4 (VCC), U2.7 (VCC), UNK2.2, UNK3.2; also elsewhere on the board

Notes on the sheet:
https://xiehaotian.com/linuxpc/f1c200s-xht-core
https://space.bilibili.com/1855864901

Parts:
C44, C45, C46, C47: 22uF; C_0603_1608Metric
C48, C49, C50, C51: 220pF; C_0402_1005Metric
C52, C53, C54, C55: 10uF; C_0603_1608Metric
C56: 1uF; C_0402_1005Metric
L5, L6, L7, L8: 1.5uH; L_1008_2520Metric
R32: 68K; R_0603_1608Metric
R33: 82K; R_0603_1608Metric
R34: 470K; R_0603_1608Metric
R35, R37: 150K; R_0603_1608Metric
R36: 680K; R_0603_1608Metric
R38: 18.7K; R_0603_1608Metric
R39: 5.1K; R_0603_1608Metric
U3: EA3059; QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm; MANUFACTURER PART EA3056QDR; LCSC PART NAME 集成电路DC-DC

Connections:
+1V1: C44.1, L5.1, R32.1; also elsewhere on the board
+2V5: C45.1, L6.1, R34.1; also elsewhere on the board
+2V8: C47.1, L8.1, R38.1; also elsewhere on the board
+3V3: C46.1, L7.1, R36.1; also elsewhere on the board
/POWER/EA_LX1: C48.1, L5.2, U3.12 (LX1)
/POWER/EA_LX2: C49.1, L6.2, U3.7 (LX2)
/POWER/EA_LX3: C50.1, L7.2, U3.24 (LX3)
/POWER/EA_LX4: C51.1, L8.2, U3.19 (LX4)
GND: C44.2, C45.2, C46.2, C47.2, C52.2, C53.2, C54.2, C55.2, C56.2, R33.2, R35.2, R37.2, R39.2, U3.1 (GND3), U3.4 (AGND), U3.6 (GND2), U3.13 (GND1), U3.18 (GND4), U3.25 (PAD); also elsewhere on the board
unnamed: C48.2, R32.2, R33.1, U3.14 (FB1)
unnamed: C49.2, R34.2, R35.1, U3.5 (FB2)
unnamed: C50.2, R36.2, R37.1, U3.2 (FB3)
unnamed: C51.2, R38.2, R39.1, U3.17 (FB4)
VBUS: C52.1, C53.1, C54.1, C55.1, C56.1, U3.3 (VCC), U3.8 (VIN2), U3.9 (EN2), U3.10 (EN1), U3.11 (VIN1), U3.20 (VIN4), U3.21 (EN4), U3.22 (EN3), U3.23 (VIN3); also elsewhere on the board

Notes on the sheet:
100MA
DC/DC1
VDD 2.5V FOR SOC DRAM
3.3V@2A
150MA
650MA
VDD 3.3V FOR SOC、SCREEN、SD
VCC 1V1 FOR SOC
DC/DC2
VCC 2.8V FOR SOC
2.5V@2A
2.8V@2A
DC/DC3
1.1V@2A
DC/DC4

Parts:
C14, C16, C21, C57: 0.1uF; C_0603_1608Metric
C15: 10uF; C_0603_1608Metric
C43: 0.1uF; C_0402_1005Metric
CN1: PJ-393_8PJ; AUDIO-SMD_PJ-393-8PJ
D1, D2, D3, D4, D5: 1N5819; D_SOD-323
D6, D7, D9, D15, D16, D17, D18, D19, D20, D21: AU0511P1; D_0402_1005Metric
J2: Micro_SD_Card_Det; TF-SMD_HYCW104-TF08-375B
R2, R3, R5, R6, R7: 4.7K; R_0603_1608Metric
R15, R44, R45: 22R; R_0603_1608Metric
R31, R40, R41, R42, R43: 10K; R_0402_1005Metric
R46, R47: 33R; R_0603_1608Metric
R48: 0R; R_0402_1005Metric
UNK1: GMT02401; LCD_GMT024-01

Connections:
+3V3: C14.1, C15.1, C43.1, D18.2 (A2), J2.4 (VDD), R2.1, R3.1, R5.1, R6.1, R7.1, R31.1, R40.1, R41.1, R42.1, R43.1, UNK1.8 (VCC), UNK1.9 (A); also elsewhere on the board
/AUDIO&SCREEN&SD/GMT_CS: D1.2 (A), R2.2, UNK1.5 (CS)
/AUDIO&SCREEN&SD/GMT_DC: D2.2 (A), R3.2, UNK1.4 (DC)
/AUDIO&SCREEN&SD/GMT_RES: D3.2 (A), R5.2, UNK1.2 (RST)
/AUDIO&SCREEN&SD/GMT_SCL: D5.2 (A), R7.2, UNK1.3 (SCL)
/AUDIO&SCREEN&SD/GMT_SDA: D4.2 (A), R6.2, UNK1.6 (SDA)
GND: C14.2, C15.2, C16.2, C21.2, C43.2, C57.2, D6.1 (A1), D7.1 (A1), D9.1 (A1), D15.1 (A1), D16.1 (A1), D17.1 (A1), D18.1 (A1), D19.1 (A1), D20.1 (A1), D21.1 (A1), J2.6 (VSS), UNK1.1 (GND), UNK1.10 (K); also elsewhere on the board
HPCOM: CN1.8, D9.2 (A2), R15.1, R48.1; also elsewhere on the board
HPCOMFB: R48.2; also elsewhere on the board
HPL: R45.1, R46.1; also elsewhere on the board
HPR: R44.1, R47.1; also elsewhere on the board
LCD_CS: D1.1 (K); also elsewhere on the board
LCD_DC: D2.1 (K); also elsewhere on the board
LCD_RST: D3.1 (K); also elsewhere on the board
LCD_SCL: D5.1 (K); also elsewhere on the board
LCD_SDA: D4.1 (K); also elsewhere on the board
unnamed: C16.1, R15.2
unnamed: C21.1, R44.2
unnamed: C57.1, R45.2
unnamed: CN1.4, D6.2 (A2), R46.2
unnamed: CN1.6, D7.2 (A2), R47.2
SDC0_CLK: D19.2 (A2), J2.5 (CLK); also elsewhere on the board
SDC0_CMD: D17.2 (A2), J2.3 (CMD), R31.2; also elsewhere on the board
SDC0_D0: D20.2 (A2), J2.7 (DAT0), R42.2; also elsewhere on the board
SDC0_D1: D21.2 (A2), J2.8 (DAT1), R43.2; also elsewhere on the board
SDC0_D2: D15.2 (A2), J2.1 (DAT2), R41.2; also elsewhere on the board
SDC0_D3: D16.2 (A2), J2.2 (DAT3/CD), R40.2; also elsewhere on the board

Notes on the sheet:
https://space.bilibili.com/1855864901
https://xiehaotian.com/linuxpc/f1c200s-xht-core

Parts:
AE1: Antenna_Shield; Texas_SWRA117D_2.4GHz_Left
C1, C2, C7, C8, C12, C20: 0.1uF; C_0402_1005Metric
C3, C5, C13: 10uF; C_0402_1005Metric
C4: 2.4pF; C_0402_1005Metric
C6: 8.2pF; C_0402_1005Metric
C9: 1uF; C_0402_1005Metric
C10, C11: 18pF; C_0402_1005Metric
D8: LED; LED_0603_1608Metric
L1: 4.3nH; L_0402_1005Metric
L2: 1.5nH; L_0402_1005Metric
R1, R4, R8, R9, R10, R11, R12, R13, R14, R16: 10K; R_0402_1005Metric
R17: 470R; R_0402_1005Metric
SW1: EVQPUC02K; SW-SMD_EVQPUD02K; VOLTAGE RATING (DC) 12V; MANUFACTURER PART EVQPUC02K; LCSC PART NAME 4.7*4.5*1.65mm 卧贴 轻触开关 行程0.3mm 侧按
TP3, TP7, TP8, TP9: TestPoint; TestPoint_Pad_D1.5mm
U1: ESP8266EX; QFN50P500X500X80-33N; MANUFACTURER PART ESP8266EX; LCSC PART NAME ESP8266EX
Y1: 26M; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3V3: C1.1, C2.1, C3.1, C5.1, C7.1, C8.1, C12.1, C13.1, D8.2 (A), L1.1, R4.1, R8.1, R9.1, R10.2, R11.2, R12.2, R13.2, U1.1 (VDDA), U1.11 (VDDPST), U1.17 (VDD_PST), U1.29 (VDDD), U1.30 (VDDA); also elsewhere on the board
/WIFI/ADC: U1.6 (TOUT)
/WIFI/ESP8266EX_VDD: L1.2, U1.3 (VDD3P3), U1.4 (VDD3P3)
/WIFI/ESP_RX: TP7.1, U1.25 (U0_RXD)
/WIFI/ESP_TX: TP3.1, U1.26 (U0_TXD)
/WIFI/GPIO0: R10.1, U1.15 (GPIO0)
/WIFI/GPIO2: R13.1, R16.2, U1.14 (GPIO2)
/WIFI/GPIO4: TP8.1, U1.16 (GPIO4)
/WIFI/GPIO5: TP9.1, U1.24 (GPIO5)
/WIFI/GPIO9: U1.18 (SD_D2)
/WIFI/GPIO12: U1.10 (MTDI/GPIO12)
/WIFI/GPIO13: U1.12 (MTCK/GPIO13)
/WIFI/GPIO14: U1.9 (MTMS/GPIO14)
/WIFI/GPIO15: R14.1, U1.13 (MTDO/GPIO15)
/WIFI/GPIO16: U1.8 (XPD_DCDC)
/WIFI/RST: C20.2, R12.1, R17.2, SW1.3
/WIFI/nRST: C9.2, R4.2, R17.1, U1.32 (EXT_RSTB)
ESP_CHIP_EN: R11.1, U1.7 (CHIP_EN); also elsewhere on the board
ESP_SD_CLK: R9.2, U1.21 (SD_CLK); also elsewhere on the board
ESP_SD_CMD: R8.2, U1.20 (SD_CMD); also elsewhere on the board
ESP_SD_D0: U1.22 (SD_D0); also elsewhere on the board
ESP_SD_D1: U1.23 (SD_D1); also elsewhere on the board
ESP_SD_D3: U1.19 (SD_D3); also elsewhere on the board
GND: AE1.2 (Shield), C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C8.2, C9.1, C10.2, C11.2, C12.2, C13.2, C20.1, L2.2, R1.1, R14.2, SW1.2, SW1.4, U1.33 (GND), Y1.2, Y1.4; also elsewhere on the board
unnamed: AE1.1 (A), C4.1, C6.1
unnamed: C6.2, L2.1, U1.2 (LNA)
unnamed: C10.1, U1.28 (XTAL_IN), Y1.3
unnamed: C11.1, U1.27 (XTAL_OUT), Y1.1
unnamed: D8.1 (K), R16.1
unnamed: R1.2, U1.31 (RES12K)

Notes on the sheet:
https://space.bilibili.com/1855864901
https://xiehaotian.com/linuxpc/f1c200s-xht-core

Parts:
C17, C18, C19, C24, C30, C31, C32, C33, C34, C36, C42: 0.1uF; C_0402_1005Metric
C22: 1uF; C_0402_1005Metric
C23: 4.7uF; C_0402_1005Metric
C26: 10uF; C_0402_1005Metric
C35: 0.1uF; C_0603_1608Metric
C37, C38: 15pF; C_0402_1005Metric
D14: LED; LED_0603_1608Metric
J1: Conn_02x04_Odd_Even; PinHeader_2x04_P1.27mm_Vertical_SMD
R22, R23: 22R; R_0603_1608Metric
R24: 0R; R_0603_1608Metric
R25: 200k; R_0402_1005Metric
R26, R27: 2.2k; R_0402_1005Metric
R28, R30: 10K; R_0603_1608Metric
R29: 10K; R_0402_1005Metric
SW2: EVQPUC02K; SW-SMD_EVQPUD02K; VOLTAGE RATING (DC) 12V; MANUFACTURER PART EVQPUC02K; LCSC PART NAME 4.7*4.5*1.65mm 卧贴 轻触开关 行程0.3mm 侧按
TP13: TestPoint; TestPoint_Pad_D1.5mm
UNK4: F1C200S; F1Cx00
Y2: 24M; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+1V1: C19.1, C30.2, C34.1, UNK4.22 (VDD2), UNK4.35 (VDD3), UNK4.71 (VDD); also elsewhere on the board
+2V5: C24.1, C31.1, R26.1, UNK4.30 (DRAMVCC1), UNK4.31 (DRAMVCC2), UNK4.32 (DRAMVCC3), UNK4.34 (DRAMVCC4), UNK4.36 (DRAMVCC5); also elsewhere on the board
+2V8: C26.2, UNK4.80 (AVCC); also elsewhere on the board
+3V3: C17.1, C18.1, C33.1, C36.1, C42.1, J1.1, R28.1, R29.2, R30.1, UNK4.4 (HPVCC), UNK4.5 (VCC1), UNK4.20 (VCC2), UNK4.50 (VCC3), UNK4.67 (UVCC), UNK4.73 (TVVCC); also elsewhere on the board
/F1CX00/AGND: C22.1, C23.1, R24.2, R25.1, UNK4.82 (AGND)
/F1CX00/DRAM_VREF: C31.2, C32.1, R26.2, R27.1, UNK4.33 (DRAM_VREF)
/F1CX00/F1_RX: R22.1, UNK4.49 (PE0/CSI_HSYNC)
/F1CX00/F1_TX: R23.1, UNK4.48 (PE1/CSI_VSYNC)
/F1CX00/I2C_CLK: UNK4.38 (PE11/CLK_OUT)
/F1CX00/I2C_SDA: UNK4.37 (PE12/DA_MCLK)
/F1CX00/LED: D14.1 (K), UNK4.43 (PE6/CSI_D3)
/F1CX00/MIC_IN: TP13.1, UNK4.87 (MICIN)
/F1CX00/PD0: J1.8, UNK4.6 (PD0/LCD_D2)
/F1CX00/PD1: J1.6, UNK4.7 (PD1/LCD_D3)
/F1CX00/PD2: J1.4, UNK4.8 (PD2/LCD_D4)
/F1CX00/PD3: J1.2, UNK4.9 (PD3/LCD_D5)
/F1CX00/PD4: UNK4.10 (PD4/LCD_D6)
/F1CX00/PD5: UNK4.11 (PD5/LCD_D7)
/F1CX00/PD6: UNK4.12 (PD6/LCD_D10)
/F1CX00/PD7: UNK4.13 (PD7/LCD_D11)
/F1CX00/PD8: UNK4.14 (PD8/LCD_D12)
/F1CX00/PD9: UNK4.15 (PD9/LCD_D13)
/F1CX00/PD10: UNK4.16 (PD10/LCD_D14)
/F1CX00/PD11: UNK4.17 (PD11/LCD_D15)
/F1CX00/PD12: UNK4.18 (PD12/LCD_D18)
/F1CX00/PD13: UNK4.19 (PD13/LCD_D19)
/F1CX00/PD14: UNK4.21 (PD14/LCD_D20)
/F1CX00/PD15: UNK4.23 (PD15/LCD_D21)
/F1CX00/PD16: UNK4.24 (PD16/LCD_D22)
/F1CX00/PD17: UNK4.25 (PD17/LCD_D23)
/F1CX00/PD18: UNK4.26 (PD18/LCD_CLK)
/F1CX00/PD19: UNK4.27 (PD19/LCD_DE)
/F1CX00/PD20: UNK4.28 (PD20/HSYNC)
/F1CX00/PD21: UNK4.29 (PD21/VSYNC)
/F1CX00/PE3: UNK4.46 (PE3/CSI_D0)
/F1CX00/PE9: UNK4.40 (PE9/CSI_D6)
/F1CX00/PE10: UNK4.39 (PE10/CSI_D7)
/F1CX00/RESET: C35.1, R28.2, SW2.1, UNK4.70 (RESET)
/F1CX00/SPI1_MISO: UNK4.63 (PA3/TP_Y2)
CH_RX: R23.2; also elsewhere on the board
CH_TX: R22.2; also elsewhere on the board
ESP_CHIP_EN: UNK4.42 (PE7/CSI_D4); also elsewhere on the board
ESP_SD_CLK: UNK4.59 (PC0/SPI0_CLK); also elsewhere on the board
ESP_SD_CMD: UNK4.62 (PC3/SPI0_MOSI); also elsewhere on the board
ESP_SD_D0: UNK4.61 (PC2/SPI0_MISO); also elsewhere on the board
ESP_SD_D1: UNK4.41 (PE8/CSI_D5); also elsewhere on the board
ESP_SD_D3: UNK4.60 (PC1/SPI0_CS); also elsewhere on the board
GND: C17.2, C18.2, C19.2, C24.2, C26.1, C30.1, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C42.2, J1.5, J1.7, R24.1, R27.2, SW2.2, SW2.4, UNK4.74 (TVGND), UNK4.89 (PAD), Y2.2, Y2.4; also elsewhere on the board
HPCOM: UNK4.2 (HPCOM_FB); also elsewhere on the board
HPCOMFB: UNK4.3 (HPCOM); also elsewhere on the board
HPL: UNK4.1 (HPL); also elsewhere on the board
HPR: UNK4.88 (HPR); also elsewhere on the board
LCD_CS: UNK4.66 (PA0/TP_X1); also elsewhere on the board
LCD_DC: UNK4.44 (PE5/CSI_D2); also elsewhere on the board
LCD_RST: UNK4.45 (PE4/CSI_D1); also elsewhere on the board
LCD_SCL: UNK4.64 (PA2/TP_Y1); also elsewhere on the board
LCD_SDA: UNK4.65 (PA1/TP_X2); also elsewhere on the board
unnamed: C22.2, UNK4.81 (AVRA1)
unnamed: C23.2, R25.2, UNK4.83 (AVRA2)
unnamed: C37.1, UNK4.52 (HOSCO), Y2.3
unnamed: C38.1, UNK4.51 (HOSCI), Y2.1
unnamed: D14.2 (A), R30.2
unnamed: R29.1, UNK4.47 (PE2/CSI_PCLK)
SDC0_CLK: UNK4.56 (PF2/SDC0_CLK); also elsewhere on the board
SDC0_CMD: UNK4.55 (PF3/SDC0_CMD); also elsewhere on the board
SDC0_D0: UNK4.57 (PF1/SDC0_D0); also elsewhere on the board
SDC0_D1: UNK4.58 (PF0/SDC0_D1); also elsewhere on the board
SDC0_D2: UNK4.53 (PF5/SDC0_D2); also elsewhere on the board
SDC0_D3: UNK4.54 (PF4/SDC0_D3); also elsewhere on the board
USB1_2_D+: UNK4.69 (DP); also elsewhere on the board
USB1_2_D-: UNK4.68 (DM); also elsewhere on the board
VBUS: J1.3; also elsewhere on the board

Notes on the sheet:
Screen
https://space.bilibili.com/1855864901
CODEC
USB
WIFI
UART
SD_Card
https://xiehaotian.com/linuxpc/f1c200s-xht-core
LED

Board: 4 copper layers, 60.4 x 43.4 mm, 165 parts (1 on the bottom side), 98 nets.
